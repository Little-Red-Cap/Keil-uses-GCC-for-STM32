# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  group Core/Src
    ./Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c syscalls.c sysmem.c system_stm32f1xx.c stm32f1xx_hal_timebase_tim.c
  group Core/Startup
    ./Core/Startup/: startup_stm32f103c8tx.s
  group Drivers/STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
